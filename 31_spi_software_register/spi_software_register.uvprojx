# Keil uVision project spi_software_register.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: led_register
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Start;.\Drivers\inc;.\Interface\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Drivers
    ./Drivers/src/: delay.c i2c.c key.c led.c usart.c
  group User
    ./User/: main.c
  group interface
    ./Interface/src/: at24c02.c
